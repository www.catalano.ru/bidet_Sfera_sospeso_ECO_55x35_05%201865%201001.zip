Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Bidets_Ceramica-Catalano_SFERA-55x35-wall-hung-Bidet-ECO-2.ifc
Time: 2024-05-20T11:35:13
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: SFERA 55x35 wall-hung Bidet ECO 2
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): SFERA 55x35 wall-hung Bidet ECO 2; SKU (BO_prodsku): SFERA_bidet_ECO2_sospeso_55x35_0518651001; ManufacturName (BO_Manufac): Ceramica Catalano; BrandUrl (BO_brandurl): https://www.catalano.it/; ProductFamily (BO_prodfam): Sfera; ProductGroup (BO_prodgroup): Bidet; ManufacturCountry (BO_mancont): Italy; DesignCountry (BO_designcont): Italy; EditionNumber (BO_edinum): 1; Width (BO_width): 350; Height (BO_height): 350; Depth (BO_depth): 550; Weight (BO_weight): 19; QR (BO_boqrurl): http://bimobject.com/ceramica-catalano/product/SFERA_bidet_ECO2_sospeso_55x35_0518651001; ProductDataUrl (BO_prodaturl): bimobject.com/ceramica-catalano/product/SFERA_bidet_ECO2_sospeso_55x35_0518651001; ProductUrl (BO_producturl): https://www.catalano.it/prodotti/bidet-sfera-55-sospeso-eco/; TechnicalDescription (BO_techcert): http://www.ceramicacatalano.it/allegati_schede/schede-tecniche/SFERA/Bidet_sosp-ECO_Sfera_55x35_05%201865%201001_IT.pdf; InstructionVideo (BO_youtube): https://www.youtube.com/watch?v=o2KUbWO5dNE; MaterialMain (BO_mainmat): Ceramics; MaterialSecondary (BO_secmat): Vitreous china; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Bidets; BimObjectCategoryCode (BO_bocat_code): sanitary-bidets; IfcClassification (BO_ifcclas): Sanitary Terminal; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20_06_11; Uniclass2015Description (BO_uniclass2015_desc): Bidets; OmniClassCode (BO_omniclass_code): 23-31 23 00; OmniClassDescription (BO_omniclass_name): Bidets; MasterFormat2014Code (BO_masterformat2014_code): 22 41 13.19; MasterFormat2014Description (BO_masterformat2014_name): Residential Bidets; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; RegionNorthAmerica (BO_northamerica): AG, AI, AW, BB, BL, BM, BQ, BS, BZ, CA, CR, CU, CW, DM, DO, GD, GL, GP, GT, HN, HT, JM, KN, KY, LC, MF, MQ, MS, MX, NI, PA, PM, PR, SV, SX, TC, TT, US, VC, VG, VI; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, CO, EC, FK, GF, GY, PE, PY, SR, UY, VE; RegionMiddleEast (BO_middleeast): AE, AF, BH, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BN, BT, CC, CN, CX, GE, HK, ID, IN, IO, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MO, MV, MY, NP, PH, PK, SG, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AS, AU, CK, FJ, FM, GU, KI, MH, MP, NC, NF, NR, NU, NZ, PF, PG, PN, PW, SB, TK, TL, TO, TV, UM, WF, WS, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, CV, DJ, DZ, EH, ER, ET, GA, GH, GM, GN, GQ, GW, KE, KM, LR, LS, LY, MA, MG, ML, MR, MU, MW, MZ, NA, NE, NG, RE, RW, SC, SD, SH, SL, SN, SO, SS, ST, SZ, TD, TG, TN, TZ, UG, YT, ZA, ZM, ZW; RegionAntarctica (BO_antarctica): AQ, BV, GS, HM, TF
